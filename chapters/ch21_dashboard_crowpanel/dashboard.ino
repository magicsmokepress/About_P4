/*
 * ch21_dashboard.ino — CrowPanel Advanced 7" system dashboard (panel only)
 * ---------------------------------------------------------------------------
 * Display/touch + fonts + palette all taken from the working MAH7_CrowPanel
 * project, so it looks like that app and not a from-scratch guess:
 *   - Async flush via attachDrawBitmapFinishCallback (DSI_FLICKER_FIX.md)
 *   - Single framebuffer + 2x50-line PSRAM partial buffers
 *   - Fonts 14/20/28 (this folder ships the matching lv_conf.h)
 *   - ui_common.h dark palette
 *
 * IMPORTANT — fonts: this sketch needs Montserrat 20 and 28. They are enabled
 * in the lv_conf.h shipped in THIS folder. Copy it to your LVGL config location
 * (the MAH7 project uses  libraries/lvgl/lv_conf.h ) and rebuild. Without it
 * you'll get "lv_font_montserrat_20 not declared".
 *
 * No external sensors — CPU clock, PSRAM used, heap used, uptime, live touch.
 * Board: ESP32P4 Dev Module | PSRAM: OPI PSRAM | Partition: Huge APP.
 */

#include <esp_display_panel.hpp>
#include <lvgl.h>
#include "drivers/touch/port/esp_lcd_touch.h"

using namespace esp_panel::drivers;

// ─── Fonts (match MAH7 ui_common.h) ──────────────────────────────────
#define UI_FONT_SM  &lv_font_montserrat_14
#define UI_FONT_MD  &lv_font_montserrat_20
#define UI_FONT_LG  &lv_font_montserrat_28

// ─── Palette (verbatim from MAH7 ui_common.h) ────────────────────────
#define C_BG      0x0D1117
#define C_BG2     0x161B22
#define C_BG3     0x21262D
#define C_BORDER  0x30363D
#define C_TEXT    0xC9D1D9
#define C_DIM     0x8B949E
#define C_GREEN   0x2ECC71
#define C_AMBER   0xF39C12
#define C_RED     0xE74C3C
#define C_BLUE    0x58A6FF

// ─── Display + touch config (proven CrowPanel values) ───────────────
#define LCD_WIDTH 1024
#define LCD_HEIGHT 600
#define LCD_DSI_LANE_NUM 2
#define LCD_DSI_LANE_RATE 1000
#define LCD_DPI_CLK_MHZ 52
#define LCD_COLOR_BITS ESP_PANEL_LCD_COLOR_BITS_RGB565
#define LCD_DPI_HPW 10
#define LCD_DPI_HBP 160
#define LCD_DPI_HFP 160
#define LCD_DPI_VPW 1
#define LCD_DPI_VBP 23
#define LCD_DPI_VFP 12
#define LCD_DSI_PHY_LDO_ID 3
#define LCD_RST_IO -1
#define LCD_BL_IO 31
#define LCD_BL_ON_LEVEL 1
#define TOUCH_I2C_SDA 45
#define TOUCH_I2C_SCL 46
#define TOUCH_I2C_FREQ (400 * 1000)
#define TOUCH_RST_IO 40
#define TOUCH_INT_IO 42
#define BUF_LINES 50

// ─── Globals ─────────────────────────────────────────────────────────
static LCD_EK79007       *g_lcd = NULL;
static BacklightPWM_LEDC *g_bl  = NULL;
static TouchGT911        *g_touch = NULL;
static lv_display_t      *lvgl_disp = NULL;

static lv_obj_t *cpu_arc, *cpu_val, *psram_arc, *psram_val, *heap_arc, *heap_val;
static lv_obj_t *up_val, *touch_val;
static volatile int16_t g_tx=-1, g_ty=-1; static volatile bool g_touched=false;

// ─── DMA-done ISR (the flicker fix) ──────────────────────────────────
static IRAM_ATTR bool on_dma_finish(void *user_data) {
  lv_display_flush_ready((lv_display_t *)user_data);
  return false;
}
static void lvgl_flush_cb(lv_display_t *disp, const lv_area_t *area, uint8_t *px_map) {
  LCD_EK79007 *lcd = (LCD_EK79007 *)lv_display_get_user_data(disp);
  if (lcd) lcd->drawBitmap(area->x1, area->y1,
                           area->x2 - area->x1 + 1, area->y2 - area->y1 + 1, px_map);
}
static void lvgl_touch_cb(lv_indev_t *indev, lv_indev_data_t *data) {
  TouchGT911 *touch = (TouchGT911 *)lv_indev_get_user_data(indev);
  if (!touch) { data->state = LV_INDEV_STATE_RELEASED; g_touched=false; return; }
  esp_lcd_touch_handle_t tp = touch->getHandle();
  if (!tp) { data->state = LV_INDEV_STATE_RELEASED; g_touched=false; return; }
  uint16_t x[1], y[1], st[1]; uint8_t cnt = 0;
  esp_lcd_touch_read_data(tp);
  bool pressed = esp_lcd_touch_get_coordinates(tp, x, y, st, &cnt, 1) && cnt > 0;
  if (pressed) { data->point.x=x[0]; data->point.y=y[0]; data->state=LV_INDEV_STATE_PRESSED;
                 g_tx=x[0]; g_ty=y[0]; g_touched=true; }
  else { data->state = LV_INDEV_STATE_RELEASED; g_touched=false; }
}

static void init_hardware() {
  BusDSI *bus = new BusDSI(
    LCD_DSI_LANE_NUM, LCD_DSI_LANE_RATE, LCD_DPI_CLK_MHZ, LCD_COLOR_BITS,
    LCD_WIDTH, LCD_HEIGHT, LCD_DPI_HPW, LCD_DPI_HBP, LCD_DPI_HFP,
    LCD_DPI_VPW, LCD_DPI_VBP, LCD_DPI_VFP, LCD_DSI_PHY_LDO_ID);
  bus->configDpiFrameBufferNumber(1);
  assert(bus->begin());
  g_lcd = new LCD_EK79007(bus, LCD_WIDTH, LCD_HEIGHT, LCD_COLOR_BITS, LCD_RST_IO);
  assert(g_lcd->begin());
  g_bl = new BacklightPWM_LEDC(LCD_BL_IO, LCD_BL_ON_LEVEL);
  if (g_bl->begin()) g_bl->setBrightness(0);
  BusI2C *tb = new BusI2C(TOUCH_I2C_SCL, TOUCH_I2C_SDA,
    (BusI2C::ControlPanelFullConfig)ESP_PANEL_TOUCH_I2C_CONTROL_PANEL_CONFIG(GT911));
  tb->configI2C_FreqHz(TOUCH_I2C_FREQ);
  tb->configI2C_PullupEnable(true, true);
  g_touch = new TouchGT911(tb, LCD_WIDTH, LCD_HEIGHT, TOUCH_RST_IO, TOUCH_INT_IO);
  g_touch->begin();
  lv_init();
  lv_tick_set_cb((lv_tick_get_cb_t)millis);
  uint32_t bb = LCD_WIDTH * BUF_LINES * sizeof(lv_color_t);
  void *b1 = ps_malloc(bb), *b2 = ps_malloc(bb); assert(b1 && b2);
  lvgl_disp = lv_display_create(LCD_WIDTH, LCD_HEIGHT);
  lv_display_set_buffers(lvgl_disp, b1, b2, bb, LV_DISPLAY_RENDER_MODE_PARTIAL);
  lv_display_set_flush_cb(lvgl_disp, lvgl_flush_cb);
  lv_display_set_user_data(lvgl_disp, g_lcd);
  g_lcd->attachDrawBitmapFinishCallback(on_dma_finish, (void *)lvgl_disp);
  lv_indev_t *indev = lv_indev_create();
  lv_indev_set_type(indev, LV_INDEV_TYPE_POINTER);
  lv_indev_set_read_cb(indev, lvgl_touch_cb);
  lv_indev_set_user_data(indev, g_touch);
}

// ─── Ring gauge (vector arc + 28px center value + 20px caption) ──────
static void make_ring(lv_obj_t*parent, int x_off, uint32_t color,
                      const char*caption, lv_obj_t**out_arc, lv_obj_t**out_val) {
  lv_obj_t *arc = lv_arc_create(parent);
  lv_obj_set_size(arc, 250, 250);
  lv_obj_align(arc, LV_ALIGN_TOP_MID, x_off, 95);
  lv_arc_set_rotation(arc, 135);
  lv_arc_set_bg_angles(arc, 0, 270);
  lv_arc_set_range(arc, 0, 100);
  lv_arc_set_value(arc, 0);
  lv_obj_remove_flag(arc, LV_OBJ_FLAG_CLICKABLE);
  lv_obj_set_style_arc_width(arc, 22, LV_PART_MAIN);
  lv_obj_set_style_arc_color(arc, lv_color_hex(C_BORDER), LV_PART_MAIN);
  lv_obj_set_style_arc_width(arc, 22, LV_PART_INDICATOR);
  lv_obj_set_style_arc_color(arc, lv_color_hex(color), LV_PART_INDICATOR);
  lv_obj_set_style_arc_rounded(arc, true, LV_PART_INDICATOR);
  lv_obj_set_style_opa(arc, LV_OPA_TRANSP, LV_PART_KNOB);
  lv_obj_t *v = lv_label_create(arc);
  lv_label_set_text(v, "--");
  lv_obj_set_style_text_font(v, UI_FONT_LG, 0);
  lv_obj_set_style_text_color(v, lv_color_hex(C_TEXT), 0);
  lv_obj_center(v);
  lv_obj_t *cap = lv_label_create(parent);
  lv_label_set_text(cap, caption);
  lv_obj_set_style_text_font(cap, UI_FONT_MD, 0);
  lv_obj_set_style_text_color(cap, lv_color_hex(color), 0);
  lv_obj_align_to(cap, arc, LV_ALIGN_OUT_BOTTOM_MID, 0, 8);
  *out_arc = arc; *out_val = v;
}

static lv_obj_t* make_chip(lv_obj_t*parent, int x, const char*caption, uint32_t color) {
  lv_obj_t *box = lv_obj_create(parent);
  lv_obj_set_size(box, 300, 92); lv_obj_set_pos(box, x, 488);
  lv_obj_set_style_bg_color(box, lv_color_hex(C_BG2), 0);
  lv_obj_set_style_border_color(box, lv_color_hex(C_BORDER), 0);
  lv_obj_set_style_radius(box, 10, 0);
  lv_obj_remove_flag(box, LV_OBJ_FLAG_SCROLLABLE);
  lv_obj_t *c = lv_label_create(box);
  lv_label_set_text(c, caption); lv_obj_set_style_text_font(c, UI_FONT_SM, 0);
  lv_obj_set_style_text_color(c, lv_color_hex(color), 0);
  lv_obj_align(c, LV_ALIGN_TOP_LEFT, 0, 0);
  lv_obj_t *v = lv_label_create(box);
  lv_label_set_text(v, "--"); lv_obj_set_style_text_font(v, UI_FONT_MD, 0);
  lv_obj_set_style_text_color(v, lv_color_hex(C_TEXT), 0);
  lv_obj_align(v, LV_ALIGN_BOTTOM_LEFT, 0, -2);
  return v;
}

static void build_ui() {
  lv_obj_t *scr = lv_screen_active();
  lv_obj_set_style_bg_color(scr, lv_color_hex(C_BG), 0);
  lv_obj_set_style_bg_opa(scr, LV_OPA_COVER, 0);

  lv_obj_t *hdr = lv_obj_create(scr);
  lv_obj_set_size(hdr, 1024, 64); lv_obj_set_pos(hdr, 0, 0);
  lv_obj_set_style_bg_color(hdr, lv_color_hex(C_BG2), 0);
  lv_obj_set_style_border_width(hdr, 0, 0);
  lv_obj_set_style_radius(hdr, 0, 0);
  lv_obj_remove_flag(hdr, LV_OBJ_FLAG_SCROLLABLE);
  lv_obj_t *h = lv_label_create(hdr);
  lv_label_set_text(h, "ESP32-P4  System Monitor");
  lv_obj_set_style_text_font(h, UI_FONT_LG, 0);
  lv_obj_set_style_text_color(h, lv_color_hex(C_TEXT), 0);
  lv_obj_align(h, LV_ALIGN_LEFT_MID, 24, 0);
  lv_obj_t *h2 = lv_label_create(hdr);
  lv_label_set_text(h2, "CrowPanel Advanced 7\"");
  lv_obj_set_style_text_font(h2, UI_FONT_SM, 0);
  lv_obj_set_style_text_color(h2, lv_color_hex(C_DIM), 0);
  lv_obj_align(h2, LV_ALIGN_RIGHT_MID, -24, 0);

  make_ring(scr, -340, C_GREEN, "CPU  /  400 MHz", &cpu_arc,   &cpu_val);
  make_ring(scr,    0, C_AMBER, "PSRAM USED",      &psram_arc, &psram_val);
  make_ring(scr,  340, C_BLUE,  "HEAP USED",       &heap_arc,  &heap_val);

  up_val    = make_chip(scr, 112, "UPTIME",              C_DIM);
  touch_val = make_chip(scr, 612, "TOUCH  (tap screen)", C_BLUE);
}

static void update_metrics() {
  uint32_t cpu = getCpuFrequencyMhz();
  lv_arc_set_value(cpu_arc, (int)(cpu * 100 / 400));
  lv_label_set_text_fmt(cpu_val, "%lu", (unsigned long)cpu);

  size_t pst = ESP.getPsramSize(), psf = ESP.getFreePsram();
  int pu = pst ? (int)((pst - psf) * 100 / pst) : 0;
  lv_arc_set_value(psram_arc, pu);
  lv_label_set_text_fmt(psram_val, "%d%%", pu);

  size_t ht = ESP.getHeapSize(), hf = ESP.getFreeHeap();
  int hu = ht ? (int)((ht - hf) * 100 / ht) : 0;
  lv_arc_set_value(heap_arc, hu);
  lv_label_set_text_fmt(heap_val, "%d%%", hu);

  uint32_t s = millis() / 1000;
  lv_label_set_text_fmt(up_val, "%02u:%02u:%02u",
    (unsigned)(s/3600), (unsigned)((s/60)%60), (unsigned)(s%60));
}

void setup() {
  Serial.begin(115200); delay(500);
  Serial.println("\nCrowPanel ESP32-P4 System Monitor");
  init_hardware();
  build_ui();
  for (int i=0;i<5;i++){ lv_timer_handler(); delay(20); }
  if (g_bl) g_bl->setBrightness(100);
  update_metrics();
}

void loop() {
  static uint32_t last=0;
  if (millis()-last > 1000) {
    last = millis();
    update_metrics();
    if (g_touched) lv_label_set_text_fmt(touch_val, "%d, %d", g_tx, g_ty);
  }
  lv_timer_handler();
  delay(5);
}
